## sysdrv/drv_ko/sx1276/Kconfig
```kconfig
config SX1278
tristate "Semtec sx1278 support"
default y
help
  Semtec sx1278 Support for file-ops
```
